# Keil uVision project demoTask.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demoTask
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Task\inc;..\..\Task\cfg\inc;..\..\Task\port\cortex-m4;..\..\Task\pt_thread
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HFxxxLLx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c
  group Task
    ../../Task/src/: task.c task_hook.c
  group PT
    ../../Task/pt_thread/: pt_timer.c
  group TaskCfg
    ../../Task/cfg/src/: task_cfg.c
  group Taskport
    ../../Task/port/cortex-m4/: task_port.c
software components: CMSIS:CORE 5.6.0, Board Support:LED 1.0.0, Device:SDK Driver:Clock 4.0.2, Device:SDK Driver:Interrupt 4.0.2, Device:SDK Driver:PINS 4.0.2, Device:Startup 2.0.0
